# Keil uVision project receiver_STM32.uvproj, settings and files
target Simu_F103 (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: firmware_receiver_STM32
  AfterMake: "C:\Program Files (x86)\CodeSourcery\Sourcery G++ Lite\bin\arm-none-eabi-size.exe" release\*.elf
  group Boot
    ../system/stm32f103/: startup-gcc.S
  group Drivers
    ../drivers/clock/: clock.c clock.h
    ../drivers/usart/: usart.c usart.h
    ../drivers/xprintf/: xprintf.c xprintf.h
  group Services
    ../src/: serialComm.c serialComm.h
  group Application
    ../src/: main.c
target Reel_F103 (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: receiver_STM32
  AfterMake: as above
